# Keil uVision project F103C8T6.uvprojx, settings and files
target F103C8T6 (6240000::V6.24::ARMCLANG)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: F103C8T6 +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,STM32F103xB
  c include: ../Core/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc/Legacy;../Drivers/STM32F1xx_HAL_Driver/Inc;../Drivers/CMSIS/Device/ST/STM32F1xx/Include;../Drivers/CMSIS/Include;../User
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Application/MDK-ARM
    ./: startup_stm32f103xb.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c dma.c usart.c usb.c stm32f1xx_it.c stm32f1xx_hal_msp.c
  group User
    ../User/: remote_link.c my_main.c my_main.h remote_link.h
  group Drivers/STM32F1xx_HAL_Driver
    ../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_uart.c stm32f1xx_hal.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_dma.c stm32f1xx_hal_cortex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_exti.c stm32f1xx_hal_pcd.c stm32f1xx_hal_pcd_ex.c stm32f1xx_ll_usb.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f1xx.c
software components: CMSIS:CORE 5.0.1
