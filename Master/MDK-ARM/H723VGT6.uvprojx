# Keil uVision project H723VGT6.uvprojx, settings and files
target H723VGT6 (6180000::V6.18::ARMCLANG)
  device: STM32H723VGTx STMicroelectronics
  pack: Keil.STM32H7xx_DFP.4.1.3
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x24000000-0x2404FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(12000000) FPU3(DFPU) CPUTYPE("Cortex-M7") ELITTLE TZ
  output: H723VGT6 +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=5 wLevel=3
  c define: USE_PWR_LDO_SUPPLY,USE_HAL_DRIVER,STM32H723xx
  c misc: -fno-finite-math-only
  c include: ../Core/Inc;../Drivers/STM32H7xx_HAL_Driver/Inc;../Drivers/STM32H7xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32H7xx/Include;../Drivers/CMSIS/Include;../Drivers/CMSIS/DSP/Include;../Drivers/CMSIS/RTOS2/Include;../Middlewares/Third_Party/FreeRTOS/Source/include;../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2;../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F;../Middlewares/Third_Party/FreeRTOS/Source/portable/GCC/ARM_CM7/r0p1;../User/Algorithm/PID;../User/Algorithm;../User/Algorithm/Gravity;../User/Algorithm/Quintic;../User/Algorithm/Trapezoid;../User/Algorithm/c_bridge;../User/Algorithm/qpOASES/include;../User/Communication;../User/Driver;../User/Driver/Verison;../User/Driver/Motor;../User/Driver/Motor/DJ_M2006;../User/Driver/Motor/DJ_M3508;../User/Driver/Motor/DM_J4310;../User/Driver/Motor/RS_00;../User/Driver/Motor/RS_01;../User/Driver/Motor/RS_05;../User/Peripheral/CAN;../User/Peripheral/UART;../User/Peripheral/Encoder;../User/Peripheral/Flash;../User/Mechanism/Upper;../User/Mechanism/Robot;../User/Task;../User/App;../User/Mechanism/Chassis;../User/Communication/ethernet
  asm include: ../Core/Inc;../Drivers/STM32H7xx_HAL_Driver/Inc;../Drivers/STM32H7xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32H7xx/Include;../Drivers/CMSIS/Include;../Drivers/CMSIS/DSP/Include;../Drivers/CMSIS/RTOS2/Include;../Middlewares/Third_Party/FreeRTOS/Source/include;../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2;../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F;../Middlewares/Third_Party/FreeRTOS/Source/portable/GCC/ARM_CM7/r0p1;../User/Algorithm/PID;../User/Algorithm;../User/Algorithm/Gravity;../User/Algorithm/Quintic;../User/Algorithm/Trapezoid;../User/Algorithm/c_bridge;../User/Algorithm/qpOASES/include;../User/Communication;../User/Driver;../User/Driver/Verison;../User/Driver/Motor;../User/Driver/Motor/DJ_M2006;../User/Driver/Motor/DJ_M3508;../User/Driver/Motor/DM_J4310;../User/Driver/Motor/RS_00;../User/Driver/Motor/RS_01;../User/Driver/Motor/RS_05;../User/Peripheral/CAN;../User/Peripheral/UART;../User/Peripheral/Encoder;../User/Peripheral/Flash;../User/Mechanism/Upper;../User/Mechanism/Robot;../User/Task;../User/App
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x24000000 size 0x50000
  scatter file: .\uart_dma.sct
  group Application/MDK-ARM
    ./: startup_stm32h723xx.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c freertos.c bdma.c dma.c fdcan.c spi.c usart.c stm32h7xx_it.c stm32h7xx_hal_msp.c stm32h7xx_hal_timebase_tim.c
  group Drivers/STM32H7xx_HAL_Driver
    ../Drivers/STM32H7xx_HAL_Driver/Src/: stm32h7xx_hal_tim.c stm32h7xx_hal_tim_ex.c stm32h7xx_hal_cortex.c stm32h7xx_hal_rcc.c stm32h7xx_hal_rcc_ex.c stm32h7xx_hal_flash.c stm32h7xx_hal_flash_ex.c stm32h7xx_hal_gpio.c stm32h7xx_hal_hsem.c stm32h7xx_hal_dma.c stm32h7xx_hal_dma_ex.c stm32h7xx_hal_mdma.c stm32h7xx_hal_pwr.c stm32h7xx_hal_pwr_ex.c stm32h7xx_hal.c stm32h7xx_hal_i2c.c stm32h7xx_hal_i2c_ex.c stm32h7xx_hal_exti.c stm32h7xx_hal_fdcan.c stm32h7xx_hal_spi.c stm32h7xx_hal_spi_ex.c stm32h7xx_hal_uart.c stm32h7xx_hal_uart_ex.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32h7xx.c
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/GCC/ARM_CM7/r0p1/: port.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/Common/: mpu_wrappers_v2.c
    ../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2/: cmsis_os2.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
  group Docx
    ../User/Docx/: Project.md
  group Algorithm
    ../User/Algorithm/Gravity/: gravity.c gravity.h
    ../User/Algorithm/PID/: pid.c pid.h
    ../User/Algorithm/Quintic/: quintic_planner.c quintic_planner.h
    ../User/Algorithm/: path_follow.c
    ../User/Algorithm/Trapezoid/: trapezoid_planner.c trapezoid_planner.h
  group Peripheral
    ../User/Peripheral/CAN/: bsp_can.c bsp_can.h
    ../User/Peripheral/Flash/: flash.c flash.h
    ../User/Peripheral/UART/: bsp_uart.c bsp_uart.h
  group Communication
    ../User/Communication/: scram.c scram.h remote.c remote.h board_can.c board_can.h mins_imu.c mins_imu.h dt35.c dt35.h vofa.c vofa.h
    ../User/Communication/ethernet/: ethernet.c ethernet.h socket.c socket.h w5500.c w5500.h wizchip_conf.c wizchip_conf.h
  group Driver
    ../User/Driver/Motor/DJ_M2006/: m2006.c m2006.h
    ../User/Driver/Motor/DJ_M3508/: m3508.c m3508.h
    ../User/Driver/Motor/DM_J4310/: j4310.c j4310.h
    ../User/Communication/: board_can.h
    ../User/Driver/Motor/RS_00/: rs00.c rs00.h
    ../User/Driver/Motor/RS_05/: rs05.c rs05.h
    ../User/Driver/Motor/RS_01/: rs01.c rs01.h
    ../User/Driver/Verison/: STP-23L.c STP-23L.h
  group Mechanism
    ../User/mechanism/Robot/: robot.c robot.h
    ../User/mechanism/Upper/: upper.c upper.h
    ../User/Mechanism/Upper/: arm_config.h
    ../User/Mechanism/Chassis/: chassis.c chassis.h
  group Task
    ../User/Task/: arm_task.c arm_task.h my_main.c my_main.h status_task.c status_task.h cup_task.c cup_task.h chassis_task.c chassis_task.h
software components: CMSIS:CORE 5.0.1
